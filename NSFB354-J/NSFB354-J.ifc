Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-12-11T13:12:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Dec 11 13:12:54 2023 * Host: ZILBY3SGS3 * Database: C:\Users\SMalaya\AppData\Local\Temp\b033b9b0-420a-4349-b9e1-3063a44ec7fa\5ee405c8-ce4f-4fdb-b93c-be9a319922e3\ifc * Database version: 5507 * Database creation date: Mon Dec 11 13:12:53 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Dec 11 13:12:53 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Dec 11 13:12:53 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: NSFB354-J:NSFB354-J, NSFB354-J:NSFB354-J:763104
In: Level 1
Type - Material: Metal - Steel - Stainless - Chrome
Type - Pset_ManufacturerTypeInformation - Manufacturer: www.justmfg.com
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: NSFB354-J
Pset_DistributionFlowElementCommon - Reference: NSFB354-J; sets with these values: 2
